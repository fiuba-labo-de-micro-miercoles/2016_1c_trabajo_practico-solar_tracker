;-------------------------------------------------------------------------

							MOTORS.inc

;-------------------------------------------------------------------------

MOTORS_INIT:
	RCALL MOTOR_AZIMUT_OFF
	RCALL MOTOR_ELEVATION_OFF
RET

MOTOR_AZIMUT_LEFT:
	PUSH AUX
	PUSHI SREG



	POPI SREG
	POP AUX
RET

MOTOR_AZIMUT_RIGHT:
	PUSH AUX
	PUSHI SREG



	POPI SREG
	POP AUX
RET

MOTOR_AZIMUT_OFF:
	PUSH AUX
	PUSHI SREG
	CLR AUX
	RPWM MOTOR_AZIMUT
	POPI SREG
	POP AUX
RET

MOTOR_ELEVATION_UP:
	PUSH AUX
	PUSHI SREG



	POPI SREG
	POP AUX
RET

MOTOR_ELEVATION_DOWN:
	PUSH AUX
	PUSHI SREG



	POPI SREG
	POP AUX
RET

MOTOR_ELEVATION_OFF:
	PUSH AUX
	PUSHI SREG
	CLR AUX
	RPWM MOTOR_ELEVATION
	POPI SREG
	POP AUX
RET
